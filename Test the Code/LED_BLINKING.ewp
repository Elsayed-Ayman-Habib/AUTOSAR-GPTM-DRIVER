# IAR project LED_BLINKING.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: App.c App.h Common_Macros.h Compiler.h cstartup_code.c Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h Gpt_Lcfg.c Gpt_Regs.h Gptm.c Gptm.h Gptm_Cfg.h IntCtrl.c IntCtrl.h IntCtrl_Cfg.h IntCtrl_Lcfg.c IntCtrl_Regs.h Led.c Led.h Led_Cfg.h main.c Platform_Types.h Port.c Port.h Port_Cfg.h Port_Lcfg.c Port_Regs.h Std_Types.h tm4c123gh6pm_registers.h
